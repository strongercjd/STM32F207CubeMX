# Keil uVision project LED.uvprojx, settings and files
target LED (ARM-ADS)
  device: STM32F207VCTx STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: LED +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx
  c include: ../Core/Inc;../Drivers/STM32F2xx_HAL_Driver/Inc;../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F2xx/Include
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f2xx_it.c stm32f2xx_hal_msp.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f2xx.c
software components: CMSIS:CORE 4.3.0
